Commit message: roid1_{large,middle,small}_feet.urdf

File: URDF/roid1_large_feet.urdf (robot description, URDF)
Before this commit: robot Roid1, 25 links, 24 joints
Links:
- link c_chest: geometry visual mesh filename=package://roid1/URDF/roid1_description/meshes/c_chest_a.stl
